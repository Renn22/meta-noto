
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansThai-hinted.zip"
SRC_URI[sha256sum] = "4d49fb76ee02a3e77317461e83c0b66c263163d3b662363e5b06b0573892e0fc"

