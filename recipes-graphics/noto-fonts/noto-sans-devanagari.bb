
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansDevanagari-hinted.zip"
SRC_URI[sha256sum] = "6dce0ea53e31d1bc26895ede2992b0acb51836647ec0d67ab988f6b6c3aa08df"

