
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansKhmer-hinted.zip"
SRC_URI[sha256sum] = "9586cfb85d82d03a0a6e1d1f060ef7e40880023c15bf1d015e7a47ee2942d31e"

