
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansHebrew-hinted.zip"
SRC_URI[sha256sum] = "958e3b31f870a1175f83d3cf7231aac592021aa213e395fbb682238e8a0f8921"

